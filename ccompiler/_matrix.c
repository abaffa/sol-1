#include "lib/stdio.asm"

char *str = "\033[38;2;8;202;40m";
char *strWhite = "\033[38;2;255;255;255m";


int rnd_w[100] = {15, 65, 1, 39, 11, 8, 76, 27, 22, 31, 7, 33, 21, 49, 58, 53, 12, 79, 16, 4, 62, 30, 46, 67, 60, 35, 28, 47, 29, 57, 42, 23, 43, 54, 19, 34, 56, 41, 3, 5, 48, 71, 36, 32, 40, 25, 51, 55, 20, 14, 72, 26, 6, 70, 18, 77, 38, 73, 74, 13, 80, 75, 45, 10, 69, 24, 63, 52, 50, 61, 59, 66, 2, 37, 17, 68, 9, 78, 64, 44};

int rnd_h[100] = {13, 24, 19, 16, 15, 21, 22, 23, 10, 3, 8, 14, 5, 6, 7, 17, 2, 11, 18, 1, 20, 9, 12, 4};
int ii = 100;
char c_ref [100] = {'9','\'','.','3','5','#',',',':','%',';','"',')','2','/','<','(','*','7','$','!','1','6','4','&','-','8','=','0','+','>','\\', ' '};

void print(int w, int h, char c){
}


int main(){
  



    char c;

	int i;
	int w;
	int h;
	
	int ii;
	
	int start;
	
	while(1){
        

		w++; if( w >= 80) w = 0;
		h++; if( h >= 24){
			h = ii;
			if (ii == 0) ii = 1; else ii = 0;
		}
		i++; if( i >= 33) i = 0;
		
		if(start >= 100) start = 0;
     
    }
  

  //printf( "\033[1;1H\033[2J\033[?25h\033[m" );

  return 0;
}
